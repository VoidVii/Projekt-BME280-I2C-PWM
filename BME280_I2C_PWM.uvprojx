# Keil uVision project BME280_I2C_PWM.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BME280_I2C_PWM
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group dbg
    ./: GPIO.c GPIO.h main.c SysTick.c SysTick.h I2C.c I2C.h
software components: CMSIS:CORE 6.2.0, Device:Startup 1.0.1
